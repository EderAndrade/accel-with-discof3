# IAR project ArcSw.ewp, settings and files
configuration ArcSw (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303VC ST STM32F303VC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB; SYSTEM_CLOCK_ENABLED; UART_ENABLED; GPIO_ENABLED; ADC_ENABLED; I2C_ENABLED; TERMINAL_ENABLED
  ICCARM.CCIncludePath2: ..\..\HAL\STM32F3xx_HAL_Driver\Inc; ..\..\HAL\STM32F3xx_HAL_Driver\Inc\Legacy; ..\..\HAL\CMSIS\Device\ST\STM32F3xx\Include; ..\..\HAL\CMSIS\Include; ..\..\App\Inc; ..\..\API\Inc; ..\..\Driver\Inc; ..\..\Third Party\LSM303DLHC\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ArcSw.hex
  ILINK.IlinkOutputFile: ArcSw.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group API/Inc
    ../../API/Inc/: ea_api_accel.h ea_api_battery.h ea_api_led.h ea_api_log.h ea_api_sys.h
  group API/Src
    ../../API/Src/: ea_api_accel.c ea_api_battery.c ea_api_led.c ea_api_log.c ea_api_sys.c
  group App/Inc
    ../../App/Inc/: main.h
  group App/Src
    ../../App/Src/: main.c
  group Docs
    ../../Documentação/: README.txt
  group Driver/Inc
    ../../Driver/Inc/: ea_drv_adc.h ea_drv_gpio.h ea_drv_i2c.h ea_drv_system_clock.h ea_drv_uart.h
  group Driver/Src
    ../../Driver/Src/: ea_drv_adc.c ea_drv_gpio.c ea_drv_i2c.c ea_drv_system_clock.c ea_drv_uart.c
  group EWARM
    ./: startup_stm32f103xb.s
  group HAL/STMicroeletronics/CMSIS
    ../../HAL/STM32F3xx_HAL_Driver/Src/: system_stm32f3xx.c
  group HAL/STMicroeletronics/STM32F3xx_HAL_Driver/Inc
    ../../HAL/STM32F3xx_HAL_Driver/Inc/: stm32f3xx_hal.h stm32f3xx_hal_adc.h stm32f3xx_hal_adc_ex.h stm32f3xx_hal_conf.h stm32f3xx_hal_cortex.h stm32f3xx_hal_def.h stm32f3xx_hal_dma.h stm32f3xx_hal_dma_ex.h stm32f3xx_hal_exti.h stm32f3xx_hal_flash.h stm32f3xx_hal_flash_ex.h stm32f3xx_hal_gpio.h stm32f3xx_hal_gpio_ex.h stm32f3xx_hal_i2c.h stm32f3xx_hal_i2c_ex.h stm32f3xx_hal_pwr.h stm32f3xx_hal_pwr_ex.h stm32f3xx_hal_rcc.h stm32f3xx_hal_rcc_ex.h stm32f3xx_hal_tim.h stm32f3xx_hal_tim_ex.h stm32f3xx_hal_uart.h stm32f3xx_hal_uart_ex.h stm32f3xx_it.h
  group HAL/STMicroeletronics/STM32F3xx_HAL_Driver/Src
    ../../HAL/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_exti.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_msp.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_it.c
  group Third Party/LSM303DLHC/Inc
    ../../Third Party/LSM303DLHC/Inc/: lsm303dlhc.h
  group Third Party/LSM303DLHC/Src
    ../../Third Party/LSM303DLHC/Src/: lsm303dlhc.c
